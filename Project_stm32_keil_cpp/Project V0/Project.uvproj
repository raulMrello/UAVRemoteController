# Keil uVision project Project.uvproj, settings and files
target UAVRC_stm32_keil (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: AstroMando +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD
  c misc: --exceptions
  c include: ..\Libraries\CMSIS\Core\CM3;..\Libraries\STM32F10x_StdPeriph_Driver\inc;.\inc;.\src;.\src\drivers;.\src\user_APIs\GPS;..\..\src\mmf_0.10.13042015002\cpp\os;..\..\src\mmf_0.10.13042015002\cpp\port
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group libs
    ./src/user_APIs/GPS/: Lib_GPS.c
  group mmf
    ../../src/mmf_0.10.13042015002/cpp/os/: Exception.cpp Fifo.cpp List.cpp Memory.cpp OS.cpp Task.cpp Timer.cpp Topic.cpp
  group bsp_drivers
    ./src/drivers/: drv_GPIO.h drv_GPIO.c drv_TIM3.h drv_TIM3.c drv_RTC.h drv_RTC.c drv_POW.h drv_POW.c drv_UART.h drv_UART.c
  group Sysconfig
    ./inc/: stm32f10x_conf.h
    ./src/: stm32f10x_it.h stm32f10x_it.c main.cpp
  group CMSIS
    ../Libraries/CMSIS/Core/CM3/: core_cm3.h core_cm3.c system_stm32f10x.c
  group StdPeriph_Driver
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_usart.c misc.c stm32f10x_exti.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_rtc.c stm32f10x_pwr.c stm32f10x_bkp.c
  group RVMDK
    ../Libraries/CMSIS/Core/CM3/startup/arm/: startup_stm32f10x_md.s
  group Readme
    ../: README.md
