# Keil uVision project Project.uvproj, settings and files
target UAVRC_stm32_keil (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: AstroMando +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD
  c include: ..\Libraries\CMSIS\Core\CM3;..\Libraries\STM32F10x_StdPeriph_Driver\inc;.\inc;.\src;.\src\drivers;.\src\devices\dev_IR;.\src\devices\dev_Buzzer;.\src\devices\dev_GPS;.\src\devices\dev_Keypad;.\src\devices\dev_Bat;.\src\user_APIs\GPS;..\..\src\mmf_c\os;..\..\src\mmf_c\port
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ./src/: main.c stm32f10x_it.c
  group StdPeriph_Driver
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_usart.c misc.c stm32f10x_exti.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_rtc.c stm32f10x_pwr.c stm32f10x_bkp.c
    ./inc/: stm32f10x_conf.h
  group CMSIS
    ../Libraries/CMSIS/Core/CM3/: core_cm3.c system_stm32f10x.c
  group RVMDK
    ../Libraries/CMSIS/Core/CM3/startup/arm/: startup_stm32f10x_md.s
  group drivers
    ./src/drivers/: bsp_rc.h bsp_rc.c drv_UART1.h drv_UART1.c drv_UART2.h drv_UART2.c drv_GPIO.h drv_GPIO.c drv_TIM3.h drv_TIM3.c drv_TIM2.h drv_TIM2.c drv_KEY.h drv_KEY.c drv_IR.h drv_IR.c drv_GPS.h drv_GPS.c drv_RTC.h drv_RTC.c drv_POW.h drv_POW.c
  group user_APIs
    ./src/user_APIs/GPS/: Lib_GPS.h Lib_GPS.c
  group mmf_c
    ../../src/mmf_c/port/: platforms.h
    ../../src/mmf_c/os/: mmf.h Exception.h Exception.c OS.h OS.c Task.h Task.c Timer.h Timer.c Topic.h Topic.c
