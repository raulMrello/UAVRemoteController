# Keil uVision project mbed_stm32f10x_src.uvprojx, settings and files
target STM32F103C8 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: mbed_stm32f10x_src
  AfterMake: fromelf --bin -o build\mbed_stm32f10x_src_NUCLEO_F103RB.bin build\mbed_stm32f10x_src.axf
  c flags: Optim=1
  c define: TARGET_M3,  TARGET_CORTEX_M,  TARGET_STM,  TARGET_STM32F1,  TARGET_STM32F103C8,  TOOLCHAIN_ARM_MICRO,  TOOLCHAIN_ARM,  __CORTEX_M3,  ARM_MATH_CM3,  MBED_BUILD_TIMESTAMP=1429167707.34,  __MBED__=1,  TARGET_FF_ARDUINO,  TARGET_FF_MORPHO,  __ASSERT_MSG,
  c misc: --gnu --no_rtti
  c include: .;.\user-tasks;.\user-modules;.\user-libs;.\user-common;.\user-main;.\user-hsm;.\user-hsm\SysManagerHSM;.\user-hsm\KeyDecoderHSM;.\rtos\rtx\TARGET_CORTEX_M;.\rtos\rtos;.\mbed\api;.\mbed\hal;.\mbed\targets\cmsis;.\mbed\targets\cmsis\TARGET_STM\TARGET_STM32F1;.\mbed\targets\cmsis\TARGET_STM\TARGET_STM32F1\TARGET_NUCLEO_F103RB;.\mbed\targets\hal\TARGET_STM\TARGET_STM32F1;.\mbed\targets\hal\TARGET_STM\TARGET_STM32F1\TARGET_STM32F103C8T6;.\hsm-api
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  scatter file: .\mbed\targets\cmsis\TARGET_STM\TARGET_STM32F1\TARGET_STM32F103C8T6\TOOLCHAIN_ARM_MICRO\stm32f103xb.sct
  group user-modules
    ./user-modules/: MsgBroker.h MsgBroker.cpp List.h List_tpp.h
  group user-tasks
    ./user-tasks/: GpsReader.cpp KeyDecoder.cpp SysManager.cpp BeepGenerator.cpp VirtualReceiver.cpp LedFlasher.cpp JoystickSampler.cpp
  group user-main
    ./user-main/: main.cpp
  group user-libs
    ./user-libs/: GPS_UBLOX.cpp GPS_NMEA.cpp
  group user-common
    ./user-common/: Topics.h
  group user-hsm
    ./user-hsm/SysManagerHSM/: SysManagerHSM.cpp
    ./user-hsm/: MbedTimerInterface.cpp TemplateHsm.h
    ./user-hsm/KeyDecoderHSM/: KeyDecoderHSM.cpp
  group hsm-api
    ./hsm-api/: State.h
  group mbed-api
    ./mbed/api/: AnalogIn.h AnalogOut.h BusIn.h BusInOut.h BusOut.h CallChain.h CAN.h can_helper.h CircularBuffer.h CThunk.h DigitalIn.h DigitalInOut.h DigitalOut.h DirHandle.h Ethernet.h FileBase.h FileHandle.h FileLike.h FilePath.h FileSystemLike.h FunctionPointer.h I2C.h I2CSlave.h InterruptIn.h InterruptManager.h LocalFileSystem.h LowPowerTicker.h LowPowerTimeout.h LowPowerTimer.h mbed.h mbed_assert.h mbed_debug.h mbed_error.h mbed_interface.h platform.h PortIn.h PortInOut.h PortOut.h PwmOut.h RawSerial.h rtc_time.h semihost_api.h Serial.h SerialBase.h SPI.h SPISlave.h Stream.h Ticker.h Timeout.h Timer.h TimerEvent.h toolchain.h Transaction.h wait_api.h
  group mbed-common
    ./mbed/common/: assert.c board.c BusIn.cpp BusInOut.cpp BusOut.cpp CallChain.cpp CAN.cpp error.c Ethernet.cpp FileBase.cpp FileLike.cpp FilePath.cpp FileSystemLike.cpp gpio.c I2C.cpp I2CSlave.cpp InterruptIn.cpp InterruptManager.cpp LocalFileSystem.cpp lp_ticker_api.c mbed_interface.c pinmap_common.c RawSerial.cpp retarget.cpp rtc_time.c semihost_api.c Serial.cpp SerialBase.cpp SPI.cpp SPISlave.cpp Stream.cpp Ticker.cpp ticker_api.c Timeout.cpp Timer.cpp TimerEvent.cpp us_ticker_api.c wait_api.c
  group mbed-hal
    ./mbed/hal/: analogin_api.h analogout_api.h buffer.h can_api.h dma_api.h ethernet_api.h gpio_api.h gpio_irq_api.h i2c_api.h lp_ticker_api.h pinmap.h port_api.h pwmout_api.h rtc_api.h serial_api.h sleep_api.h spi_api.h ticker_api.h us_ticker_api.h
  group mbed-targets-cmsis
    ./mbed/targets/cmsis/: core_cm3.h core_cmFunc.h core_cmInstr.h
  group mbed-targets-cmsis-stm32f1
    ./mbed/targets/cmsis/TARGET_STM/TARGET_STM32F1/: stm32_hal_legacy.h stm32f1xx_hal.c stm32f1xx_hal.h stm32f1xx_hal_adc.c stm32f1xx_hal_adc.h stm32f1xx_hal_adc_ex.c stm32f1xx_hal_adc_ex.h stm32f1xx_hal_can.c stm32f1xx_hal_can.h stm32f1xx_hal_can_ex.h stm32f1xx_hal_cec.c stm32f1xx_hal_cec.h stm32f1xx_hal_conf.h stm32f1xx_hal_cortex.c stm32f1xx_hal_cortex.h stm32f1xx_hal_crc.c stm32f1xx_hal_crc.h stm32f1xx_hal_dac.c stm32f1xx_hal_dac.h stm32f1xx_hal_dac_ex.c stm32f1xx_hal_dac_ex.h stm32f1xx_hal_def.h stm32f1xx_hal_dma.c stm32f1xx_hal_dma.h stm32f1xx_hal_dma_ex.h stm32f1xx_hal_eth.c stm32f1xx_hal_eth.h stm32f1xx_hal_flash.c stm32f1xx_hal_flash.h stm32f1xx_hal_flash_ex.c stm32f1xx_hal_flash_ex.h stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio.h stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_gpio_ex.h stm32f1xx_hal_hcd.c stm32f1xx_hal_hcd.h stm32f1xx_hal_i2c.c stm32f1xx_hal_i2c.h stm32f1xx_hal_i2s.c stm32f1xx_hal_i2s.h stm32f1xx_hal_irda.c stm32f1xx_hal_irda.h stm32f1xx_hal_iwdg.c stm32f1xx_hal_iwdg.h stm32f1xx_hal_nand.c stm32f1xx_hal_nand.h stm32f1xx_hal_nor.c stm32f1xx_hal_nor.h stm32f1xx_hal_pccard.c stm32f1xx_hal_pccard.h stm32f1xx_hal_pcd.c stm32f1xx_hal_pcd.h stm32f1xx_hal_pcd_ex.c stm32f1xx_hal_pcd_ex.h stm32f1xx_hal_pwr.c stm32f1xx_hal_pwr.h stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc.h stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_rcc_ex.h stm32f1xx_hal_rtc.c stm32f1xx_hal_rtc.h stm32f1xx_hal_rtc_ex.c stm32f1xx_hal_rtc_ex.h stm32f1xx_hal_sd.c stm32f1xx_hal_sd.h stm32f1xx_hal_smartcard.c stm32f1xx_hal_smartcard.h stm32f1xx_hal_spi.c stm32f1xx_hal_spi.h stm32f1xx_hal_spi_ex.c stm32f1xx_hal_sram.c stm32f1xx_hal_sram.h stm32f1xx_hal_tim.c stm32f1xx_hal_tim.h stm32f1xx_hal_tim_ex.c stm32f1xx_hal_tim_ex.h stm32f1xx_hal_uart.c stm32f1xx_hal_uart.h stm32f1xx_hal_usart.c stm32f1xx_hal_usart.h stm32f1xx_hal_wwdg.c stm32f1xx_hal_wwdg.h stm32f1xx_ll_fsmc.c stm32f1xx_ll_fsmc.h stm32f1xx_ll_sdmmc.c stm32f1xx_ll_sdmmc.h stm32f1xx_ll_usb.c stm32f1xx_ll_usb.h
  group mbed-targets-cmsis-stm32f103c8t6
    ./mbed/targets/cmsis/TARGET_STM/TARGET_STM32F1/TARGET_STM32F103C8T6/: cmsis.h cmsis_nvic.c cmsis_nvic.h hal_tick.c hal_tick.h stm32f1xx.h stm32f103xb.h system_stm32f1xx.c system_stm32f1xx.h
  group mbed-targets-cmsis-smt32f103c8t6-arm-micro
    ./mbed/targets/cmsis/TARGET_STM/TARGET_STM32F1/TARGET_STM32F103C8T6/TOOLCHAIN_ARM_MICRO/: startup_stm32f103xb.s sys.cpp
  group mbed-targets-hal-stm32f1
    ./mbed/targets/hal/TARGET_STM/TARGET_STM32F1/: analogin_api.c gpio_api.c gpio_irq_api.c gpio_object.h i2c_api.c mbed_overrides.c PeripheralPins.h pinmap.c port_api.c pwmout_api.c rtc_api.c serial_api.c sleep.c spi_api.c us_ticker.c
  group mbed-targets-hal-stm32f103c8
    ./mbed/targets/hal/TARGET_STM/TARGET_STM32F1/TARGET_STM32F103C8T6/: device.h objects.h PeripheralNames.h PeripheralPins.c PinNames.h PortNames.h
  group rtos-rtos
    ./rtos/rtos/: Mail.h MemoryPool.h Mutex.cpp Mutex.h Queue.h rtos.h RtosTimer.cpp RtosTimer.h Semaphore.cpp Semaphore.h Thread.cpp Thread.h
  group rtos-rtx-cortexm
    ./rtos/rtx/TARGET_CORTEX_M/: cmsis_os.h HAL_CM.c os_tcb.h rt_CMSIS.c rt_Event.c rt_Event.h rt_HAL_CM.h rt_List.c rt_List.h rt_Mailbox.c rt_Mailbox.h rt_MemBox.c rt_MemBox.h rt_Mutex.c rt_Mutex.h rt_Robin.c rt_Robin.h rt_Semaphore.c rt_Semaphore.h rt_System.c rt_System.h rt_Task.c rt_Task.h rt_Time.c rt_Time.h rt_TypeDef.h RTX_CM_lib.h RTX_Conf.h RTX_Conf_CM.c
  group rtos-rtx-cortexm-m3-arm
    ./rtos/rtx/TARGET_CORTEX_M/TARGET_M3/TOOLCHAIN_ARM/: HAL_CM3.c SVC_Table.s
target NO_OPTIMIZATIONS (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: as above
  output: mbed_stm32f10x_src
  AfterMake: as above
  c flags: Optim=1
  c define: as above
  c misc: --gnu --no_rtti
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  scatter file: .\mbed\targets\cmsis\TARGET_STM\TARGET_STM32F1\TARGET_STM32F103C8T6\TOOLCHAIN_ARM_MICRO\NO_OPTIMIZATIONS.sct
